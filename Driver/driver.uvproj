# Keil uVision project driver.uvproj, settings and files
target Target 1 (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: S3C2440A Samsung
  cpu: IRAM(0x40000000-0x40000FFF) CLOCK(12000000) CPUTYPE(ARM920T)
  output: driver
  AfterMake: H:\Install\ARM\BIN40\fromelf.exe --bin --output D:/卢杰的学习资料都在这里/嵌入式/语言实践/project/output/driver.bin  D:/卢杰的学习资料都在这里/嵌入式/语言实践/project/output/driver.axf
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  memory RVCT9: RAM 0x40000000 size 0x1000
  group Source Group 1
    ./src/: driver.s
